# Keil uVision project mecm_test.uvprojx, settings and files
target mecm_test (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: GD32F450ZK GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000,0x030000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x0300000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: fuxi +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: GD32F470
  c include: ..\FWLIB\Include;..\USER;..\CORE;..\HARDWARE;..\HARDWARE\bsp\bsp_inc;..\HARDWARE\module\md_inc;..\ThirdPart\Ethercat\inc;..\ThirdPart\IMU_Driver\BMI160;..\ThirdPart\cm_backtrace\Languages\zh-CN;..\ThirdPart\cm_backtrace;..\ThirdPart\cm_backtrace\Languages\en-US;..\ThirdPart\mecm\inc;..\..\..\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x300000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CORE
    ../CORE/: startup_gd32f450_470.s
  group USR
    ./: gd32f4xx_it.c main.c system_gd32f4xx.c
  group FWLIB
    ../FWLIB/Source/: gd32f4xx_adc.c gd32f4xx_can.c gd32f4xx_crc.c gd32f4xx_ctc.c gd32f4xx_dac.c gd32f4xx_dbg.c gd32f4xx_dci.c gd32f4xx_dma.c gd32f4xx_enet.c gd32f4xx_exmc.c gd32f4xx_exti.c gd32f4xx_fmc.c gd32f4xx_fwdgt.c gd32f4xx_gpio.c gd32f4xx_i2c.c gd32f4xx_ipa.c gd32f4xx_iref.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_rtc.c gd32f4xx_sdio.c gd32f4xx_spi.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_tli.c gd32f4xx_trng.c gd32f4xx_usart.c gd32f4xx_wwdgt.c
  group HARDWARE/bsp
    ../HARDWARE/bsp/bsp_src/: bsp_iwdg.c bsp_sys.c bsp_systick.c bsp_time.c
  group HARDWARE/module
    ../HARDWARE/module/md_src/: md_app.c md_enet.c
  group MECM
    ../ThirdPart/mecm/src/: mecm_port.c
    ../../../src/: mecm_base.c mecm_coe.c mecm_config.c mecm_dc.c mecm_eeprom.c mecm_fmmu.c mecm_foe.c mecm_mailbox.c mecm_pdo.c mecm_sm.c
